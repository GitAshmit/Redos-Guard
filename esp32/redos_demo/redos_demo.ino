// ReDoS Guard: ESP32 demo device.
//
// Runs the same regex two ways on the board:
//   mode=bt   backtracking matcher over the Thompson NFA (like a normal regex engine)
//   mode=dfa  minimized DFA table generated by ReDoS Guard (one lookup per character)
// With a vulnerable regex and the attack string, bt mode hangs and the task watchdog resets
// the board, while dfa mode answers immediately.
//
// Setup: 1) python -m redos.export "<regex>" > redos_tables.h  (put it in this folder)
//        2) set WIFI_SSID / WIFI_PASS below, flash with Arduino IDE (board: ESP32 Dev Module)
//        3) open http://<board-ip>/match?mode=dfa&s=aaaa!  or use the dashboard.
// Written for Arduino-ESP32 core 2.x and 3.x. Not tested on real hardware by the author.

#include <WiFi.h>
#include <WebServer.h>
#include <esp_task_wdt.h>
#include "redos_core.h"

// the default 8 KB loop-task stack is too small for deep backtracking recursion
SET_LOOP_TASK_STACK_SIZE(24 * 1024);

const char* WIFI_SSID = "CHANGE_ME";
const char* WIFI_PASS = "CHANGE_ME";
const int LED_BUSY = 2;          // on-board LED: on while a match is running
const int LED_RESULT = 4;        // external LED (optional): on = accepted, off = rejected
const uint32_t WDT_SECONDS = 3;  // how long bt mode may hang before the board resets
const size_t MAX_INPUT = 120;

WebServer server(80);

static void cors() { server.sendHeader("Access-Control-Allow-Origin", "*"); }

static const char* resetReason() {
  switch (esp_reset_reason()) {
    case ESP_RST_TASK_WDT: return "task watchdog";
    case ESP_RST_INT_WDT: return "interrupt watchdog";
    case ESP_RST_PANIC: return "panic";
    case ESP_RST_POWERON: return "power on";
    case ESP_RST_SW: return "software";
    default: return "other";
  }
}

void handleStatus() {
  cors();
  String j = "{\"regex_states\":";
  j += RG_NFA_STATES;
  j += ",\"dfa_states\":";
  j += RG_DFA_STATES;
  j += ",\"uptime_ms\":";
  j += millis();
  j += ",\"last_reset\":\"";
  j += resetReason();
  j += "\"}";
  server.send(200, "application/json", j);
}

void handleMatch() {
  cors();
  String mode = server.arg("mode");
  String s = server.arg("s");
  if (s.length() > MAX_INPUT) {
    server.send(400, "application/json", "{\"error\":\"input too long\"}");
    return;
  }
  // optional safety net: cap=<steps> makes bt mode give up instead of hanging
  uint32_t cap = server.hasArg("cap") ? (uint32_t)server.arg("cap").toInt() : 0;

  uint32_t steps = 0;
  bool capped = false, ok = false;
  digitalWrite(LED_BUSY, HIGH);
  uint32_t t0 = micros();
  if (mode == "bt") {
    ok = rg_bt_match(s.c_str(), s.length(), &steps, cap, &capped);  // may never return
  } else {
    ok = rg_dfa_match(s.c_str(), s.length(), &steps);
  }
  uint32_t dt = micros() - t0;
  digitalWrite(LED_BUSY, LOW);
  digitalWrite(LED_RESULT, ok ? HIGH : LOW);
  esp_task_wdt_reset();

  String j = "{\"mode\":\"";
  j += (mode == "bt") ? "bt" : "dfa";
  j += "\",\"matched\":";
  j += ok ? "true" : "false";
  j += ",\"steps\":";
  j += steps;
  j += ",\"micros\":";
  j += dt;
  j += ",\"capped\":";
  j += capped ? "true" : "false";
  j += "}";
  server.send(200, "application/json", j);
  Serial.printf("[%s] len=%u matched=%d steps=%u us=%u capped=%d\n", mode.c_str(),
                (unsigned)s.length(), ok, steps, dt, capped);
}

void setup() {
  Serial.begin(115200);
  pinMode(LED_BUSY, OUTPUT);
  pinMode(LED_RESULT, OUTPUT);
  Serial.printf("\nReset reason: %s\n", resetReason());

#if ESP_ARDUINO_VERSION_MAJOR >= 3
  esp_task_wdt_config_t cfg = {.timeout_ms = WDT_SECONDS * 1000, .idle_core_mask = 0, .trigger_panic = true};
  if (esp_task_wdt_init(&cfg) != ESP_OK) esp_task_wdt_reconfigure(&cfg);
#else
  esp_task_wdt_init(WDT_SECONDS, true);
#endif
  esp_task_wdt_add(NULL);  // watch the loop task: if a match hangs, the board resets

  WiFi.mode(WIFI_STA);
  WiFi.begin(WIFI_SSID, WIFI_PASS);
  while (WiFi.status() != WL_CONNECTED) {
    delay(300);
    Serial.print('.');
    esp_task_wdt_reset();
  }
  Serial.printf("\nConnected. Open http://%s/status\n", WiFi.localIP().toString().c_str());

  server.on("/status", handleStatus);
  server.on("/match", handleMatch);
  server.begin();
}

void loop() {
  server.handleClient();
  esp_task_wdt_reset();
}
